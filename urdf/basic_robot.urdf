Commit message: finish inverse kinematics

File: urdf/basic_robot.urdf (robot description, URDF)
Before this commit: robot basic_robot, 4 links, 3 joints
Links:
- link lidar_dome: geometry visual sphere radius=0.0325
Joints:
- joint chassis_to_dome: origin xyz=0.3 0 0.03125 -> xyz=0.3 0 0.0325
